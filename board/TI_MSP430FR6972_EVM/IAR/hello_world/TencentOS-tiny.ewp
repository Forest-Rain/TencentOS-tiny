# IAR project TencentOS-tiny.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR6972 MSP430FR6972
  General.GStackSize2: 1024
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pe301,Ta027
  ICC430.newCCIncludePaths: ..\..\..\..\platform\vendor_bsp\TI\MSP430FR5xx_6xx; ..\..\..\..\kernel\core\include; ..\..\..\..\kernel\pm\include; ..\..\..\..\arch\msp430\common\include; ..\..\..\..\arch\msp430\msp430x\icc430; ..\..\TOS_CONFIG; ..\..\..\..\osal\cmsis_os
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr6972.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group drivers/MSP430FR5xx_6xx
    ../../../../platform/vendor_bsp/TI/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h framctl_a.c framctl_a.h gpio.c gpio.h hspll.c hspll.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h mtif.c mtif.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h saph.c saph.h saph_a.c saph_a.h sdhs.c sdhs.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h uups.c uups.h wdt_a.c wdt_a.h
  group examples
    ../../BSP/Src/: main.c
  group tos/arch
    ../../../../arch/msp430/MSP430X/icc430/: port_c.c port_s.s43
    ../../../../arch/msp430/common/: tos_cpu.c
  group tos/kernel/core
    ../../../../kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/kernel/pm
    ../../../../kernel/pm/: tos_pm.c
